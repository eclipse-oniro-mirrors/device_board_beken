## shields/Kconfig.liteos_m.shields
```kconfig
orsource "*/Kconfig.liteos_m.defconfig.shield"

choice
    prompt "shield Selection"

    orsource "*/Kconfig.liteos_m.shield"

endchoice
```
